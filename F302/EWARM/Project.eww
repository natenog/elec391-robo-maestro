<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\elec391-robo-maestro-F302.ewp</path>
  </project>
  <batchBuild />
</workspace>
